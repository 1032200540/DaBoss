# Keil uVision project STM3210E-EVAL_Demo.uvprojx, settings and files
target STM3210E-EVAL_Demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BOOT_FLASH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\..\include;..\..\..\FWLib\library\inc;..\..\..\USBLib\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../source/: stm32f10x_it.c main.c menu.c calendar.c lcd.c hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c i2s_codec.c waveplayer.c fsmc_nor.c lowpower.c tsensor.c mass_storage.c fsmc_nand.c mass_mal.c memory.c nand_if.c scsi_data.c sdcard.c usb_bot.c usb_endp.c usb_scsi.c smartcard.c
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_adc.c
  group USBLib
    ../../../USBLib/library/src/: usb_regs.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group RVMDK
    ./: cortexm3_macro.s stm32f10x_vector.s
software components: CMSIS:CORE 4.3.0
